<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ASK0_fc</value></param>
<param><key>author</key><value>Bryce Hill</value></param>
<param><key>category</key><value>[Hill_ASK]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Basic_ASK_Xmtr</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs</value></param>
<param><key>value</key><value>a_FB*b_sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>a_FB</value></param>
<param><key>label</key><value>Baud Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>e_fcparms[0]</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>Fs</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>b_sps</value></param>
<param><key>label</key><value>Samples/Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>np.exp(1j*np.pi/180*e_fcparms[1])</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c_ptype</value></param>
<param><key>label</key><value>Pulse Type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'rect'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>d_pparms</value></param>
<param><key>label</key><value>Pulse Params</value></param>
<param><key>value</key><value>[5, .3]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>e_fcparms</value></param>
<param><key>label</key><value>fc Params</value></param>
<param><key>value</key><value>[32000, 0]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import my_grc as grc</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>b_sps</value></param>
<param><key>taps</key><value>grc.pampt(b_sps, c_ptype,d_pparms)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
