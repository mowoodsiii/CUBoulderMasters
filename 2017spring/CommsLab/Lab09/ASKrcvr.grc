<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ASKrcvr_cb</value></param>
<param><key>author</key><value>Bryce Hill</value></param>
<param><key>category</key><value>[Hill_ASK]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>ASK_Rcvr</value></param>
</block>
<block>
<key>MF0_cc</key>
<param><key>id</key><value>MF0_cc_1</value></param>
<param><key>b_FB</key><value>32000</value></param>
<param><key>a_gain</key><value>1</value></param>
<param><key>e_pparms</key><value>[5, .3]</value></param>
<param><key>d_ptype</key><value>'rect'</value></param>
<param><key>g_samp_dly</key><value>0</value></param>
<param><key>c_sps</key><value>8</value></param>
<param><key>f_fcparms</key><value>[32000, 0 ]</value></param>
</block>
<block>
<key>Y2B_fb</key>
<param><key>id</key><value>Y2B_fb_0</value></param>
<param><key>b_bpsym</key><value>int(np.real(c_bpsym))</value></param>
<param><key>a_gain</key><value>float(np.real(i_IQgain))</value></param>
<param><key>c_pol</key><value>0</value></param>
<param><key>d_sym_dly</key><value>int(np.real(k_sym_dly))</value></param>
</block>
<block>
<key>Y2B_fb</key>
<param><key>id</key><value>Y2B_fb_0_0</value></param>
<param><key>b_bpsym</key><value>int(np.real(c_bpsym))</value></param>
<param><key>a_gain</key><value>float(np.real(i_IQgain))</value></param>
<param><key>c_pol</key><value>d_pol</value></param>
<param><key>d_sym_dly</key><value>int(np.real(k_sym_dly))</value></param>
</block>
<block>
<key>Y2B_fb</key>
<param><key>id</key><value>Y2B_fb_0_1</value></param>
<param><key>b_bpsym</key><value>int(np.real(c_bpsym))</value></param>
<param><key>a_gain</key><value>float(np.real(i_IQgain))</value></param>
<param><key>c_pol</key><value>d_pol</value></param>
<param><key>d_sym_dly</key><value>int(np.real(k_sym_dly))</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>a_gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>b_FB</value></param>
<param><key>label</key><value>Baud Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c_bpsym</value></param>
<param><key>label</key><value>Bits per Symbol</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>1+1j</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>d_pol</value></param>
<param><key>label</key><value>Polar</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>e_sps</value></param>
<param><key>label</key><value>Samples/Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_ptype</value></param>
<param><key>label</key><value>Pulse Type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'rect'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>g_pparms</value></param>
<param><key>label</key><value>Pulse Params</value></param>
<param><key>value</key><value>[5, .3]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>h_fcparms</value></param>
<param><key>label</key><value>fc Params</value></param>
<param><key>value</key><value>[32000, 0]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>i_IQgain</value></param>
<param><key>label</key><value>IQ Gain</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>1+1j</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>j_samp_dly</value></param>
<param><key>label</key><value>Sample Delay</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>k_sym_dly</value></param>
<param><key>label</key><value>Symbol Delay</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>MF out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>Samples out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>Env-Data out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>I-Data out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_4</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>Q-Data out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_5</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>MF0_cc_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>MF0_cc_1</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>MF0_cc_1</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>MF0_cc_1</source_block_id><sink_block_id>pad_sink_5</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>MF0_cc_1</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Y2B_fb_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Y2B_fb_0_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Y2B_fb_0_1</source_block_id><sink_block_id>pad_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>Y2B_fb_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>Y2B_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>Y2B_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>MF0_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
