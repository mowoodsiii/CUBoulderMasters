<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ASKxmtr_bc</value></param>
<param><key>author</key><value>Bryce Hill</value></param>
<param><key>category</key><value>[Hill_ASK]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>ASK_Xmtr</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs</value></param>
<param><key>value</key><value>a_FB*d_sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>2*b_bpsym</value></param>
</block>
<block>
<key>ASK0_fc</key>
<param><key>id</key><value>ASK0_fc_0</value></param>
<param><key>a_FB</key><value>32000</value></param>
<param><key>d_pparms</key><value>[5, .3]</value></param>
<param><key>c_ptype</key><value>'rect'</value></param>
<param><key>b_sps</key><value>8</value></param>
<param><key>e_fcparms</key><value>[32000, 0]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>a_FB</value></param>
<param><key>label</key><value>Baud Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>b_bpsym</value></param>
<param><key>label</key><value>Bits per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-(M-1) if c_pol else 0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>.5 if c_pol else 1.0</value></param>
</block>
<block>
<key>blocks_packed_to_unpacked_xx</key>
<param><key>id</key><value>blocks_packed_to_unpacked_xx_0</value></param>
<param><key>bits_per_chunk</key><value>b_bpsym</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>c_pol</value></param>
<param><key>label</key><value>Polar</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>d_sps</value></param>
<param><key>label</key><value>Samples/Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>e_ptype</value></param>
<param><key>label</key><value>Pulse Type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'rect'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_pparms</value></param>
<param><key>label</key><value>Pulse Params</value></param>
<param><key>value</key><value>[5, .3]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>g_fcparms</value></param>
<param><key>label</key><value>fc Params</value></param>
<param><key>value</key><value>[32000, 0]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import my_grc as grc</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>ASK0_fc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>ASK0_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_packed_to_unpacked_xx_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_packed_to_unpacked_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
